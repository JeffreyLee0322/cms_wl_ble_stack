# Keil uVision project CMS32F030_LIB.uvprojx, settings and files
target Jeff (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: CMS32F030x Generic
  pack: Keil.CMS32F030x.1.0.5
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x7000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: CMS32F030_LIB
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Libraries\CMSIS;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\inc;..\inc;..\inc\HAL
  memory RVCT4: ROM 0x0 size 0x7000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group StartUp
    ../../../Libraries/CMSIS/: startup_CMS32F030x.s
  group Common
    ../../../Libraries/CMSIS/: system_CMS32F030x.c
  group Peripheral
    ../../../Libraries/src/: CMS32F030x_adc.c CMS32F030x_epwm.c CMS32F030x_fmc.c CMS32F030x_gpio.c CMS32F030x_iic.c CMS32F030x_pwm.c CMS32F030x_spi.c CMS32F030x_syscon.c CMS32F030x_tim.c CMS32F030x_uart.c CMS32F030x_wdt.c retarget.c
  group User
    ../src/: main.c CMS32F030x_it.c
  group HAL
    ../src/HAL/: hal_irq.c hal_spi.c hal_24g.c
